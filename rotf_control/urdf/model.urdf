Commit message: links setted up

File: rotf_control/urdf/model.urdf (robot description, URDF)
Before this commit: robot diff_bot, 5 links, 4 joints
Links:
- link base_footprint: mass None -> 0.0001; geometry visual box size=0.001 0.001 0.001
